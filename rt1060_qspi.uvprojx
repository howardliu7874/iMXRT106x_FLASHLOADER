# Keil uVision project rt1060_qspi.uvprojx, settings and files
target RT1060_QSPI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1062CVJ5A NXP
  pack: NXP.MIMXRT1062_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1060_qspi_flashloader
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Sources
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305,#66
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: bl_api.c system_MIMXRT1062.c
software components: CMSIS:CORE 5.3.0
