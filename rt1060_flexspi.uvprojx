# Keil uVision project rt1060_flexspi.uvprojx, settings and files
target RT1060_FLEXSPI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: rt1060_flexspi_flashloader
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1062CVJ5A
  c include: .\Sources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305,#66
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Sources
    ./Sources/: bl_api.c
software components: CMSIS:CORE 5.3.0
